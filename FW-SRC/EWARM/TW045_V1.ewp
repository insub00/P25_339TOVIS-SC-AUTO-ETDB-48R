# IAR project TW045_V1.ewp, settings and files
configuration TW045_V1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VC ST STM32F103VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../ZLib/M95Mxx; ../ZLib/EEPROM/Microchip_93xx76x; ../ZLib/HIMAX; ../ZLib/TCA9546APWR; ../ZLib/MICROCHIP
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TW045_GEN_019_48R_V1_IAR9.5_25xxxx.hex
  ILINK.IlinkOutputFile: TW045_V1.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Application/User/Core/inc
    ../Core/Inc/: adc.h gpio.h i2c.h main.h mytest.h packet.h spi.h stm32f1xx_hal_conf.h stm32f1xx_it.h uart.h usart.h user.h vcom.h
  group Application/User/Core/src
    ../Core/Src/: adc.c gpio.c i2c.c main.c mytest.c packet.c spi.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c uart.c usart.c user.c vcom.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group ZLib/EEPROM/Microchip_93xx76x
    ../ZLib/EEPROM/Microchip_93xx76x/: 93xx76x.c 93xx76x.h
  group ZLib/HIMAX
    ../ZLib/HIMAX/: HX8295.c HX8295.h HX8882.c HX8882.h
  group ZLib/M95Mxx
    ../ZLib/M95Mxx/: M95Mxx.c M95Mxx.h
  group ZLib/MICROCHIP
    ../ZLib/MICROCHIP/: TOUCH_ATMXT288M1T.c TOUCH_ATMXT288M1T.h
  group ZLib/TCA9546APWR
    ../ZLib/TCA9546APWR/: TCA9546APWR.c TCA9546APWR.h
